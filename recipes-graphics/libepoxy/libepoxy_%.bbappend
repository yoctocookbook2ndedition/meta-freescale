FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://Add-fallback-definition-for-EGL-CAST.patch"
